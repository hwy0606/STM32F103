# Keil uVision project LED.uvprojx, settings and files
target LED (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32 +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\Usart1_DMA;..\STM32F10x_FWLib\src;..\HARDWARE\Usart2_DMA;..\HARDWARE\Usart3_DMA;..\HARDWARE\PWM;..\HARDWARE\GPIO;..\HARDWARE\Hall_Sensor;..\HARDWARE\Key;..\HARDWARE\Encoder;..\HARDWARE\CRC_16;..\HARDWARE\Usart1_Protocol;..\HARDWARE\Usart3_Protocol;..\HARDWARE\Motor_Control;..\HARDWARE\Usart2_Protocol;..\HARDWARE\Usart5_DMA;..\HARDWARE\Usart5_Protocol;..\HARDWARE\ADC;..\HARDWARE\RCC;..\HARDWARE\SPI
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c project_config.h
  group HARDWARE
    ../HARDWARE/Usart1_DMA/: usart1_dma.c
    ../HARDWARE/Usart2_DMA/: usart2_dma.c
    ../HARDWARE/Usart3_DMA/: usart3_dma.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/Key/: key.c
    ../HARDWARE/Usart1_Protocol/: usart1_protocol.c
    ../HARDWARE/CRC_16/: crc_16.c
    ../HARDWARE/Usart3_Protocol/: usart3_protocol.c
    ../HARDWARE/GPIO/: gpio.c
    ../HARDWARE/Motor_Control/: motor_control.c
    ../HARDWARE/Usart2_Protocol/: usart2_protocol.c
    ../HARDWARE/Encoder/: encoder.c
    ../HARDWARE/RCC/: rcc.c
    ../HARDWARE/Usart5_DMA/: usart5_dma.c
    ../HARDWARE/Usart5_Protocol/: usart5_protocol.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/SPI/: spi.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_dma.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_crc.c stm32f10x_adc.c stm32f10x_spi.c
  group README
    ../: README.TXT
